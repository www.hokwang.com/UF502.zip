Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: UF502.IFC
Time: 2022-01-06T05:16:10
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 200-21
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 200-24
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 3415-06
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 3415-10_1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 3770-12_1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: AF819-01
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: AF819-02
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: AF819-05
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
